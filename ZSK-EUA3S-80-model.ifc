Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:17:19+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-EUA3S-80
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Изделие бетонное благоустройства, ZSK-EUA3S-80 Скамья «Арка 300» со спинкой
In: Площадка
Description: Изделие бетонное благоустройства. Скамья «Арка 300» со спинкой; Classification: 59.1.15.01-1076 Скамья (Классификатор строительных ресурсов (КСР)); Material: Бетон
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-EUA3S-80; ModelReference: Скамья «Арка 300» со спинкой; ProductionYear: 2026; ArticleNumber: ZSK-EUA3S-80
ORION_Изделие - Артикул: ZSK-EUA3S-80; Артикул прежний: SD-EUA3S-80; Наименование: Скамья «Арка 300» со спинкой; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 3000×450×850 мм; Материал: Бетон; Цена: 180 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/concrete/20785; Код КСИ: CPr>EDD070; Класс КСИ: Скамья; Коды КСР: 59.1.15.01-1076 … 59.1.15.02-0539
ADSK - ADSK_Наименование: Скамья «Арка 300» со спинкой; ADSK_Марка: ZSK-EUA3S-80; ADSK_Код изделия: 59.1.15.01-1076; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Бетон; ADSK_URL страницы изделия: https://зск.рф/catalog/concrete/20785
ZSK_Благоустройство - ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDD070; ZSK_Артикул_прежний: SD-EUA3S-80
Qto_ORION - Длина: 3000 mm; Ширина: 450 mm; Высота: 850 mm
